Properties of the parts of a building model (IFC4)

# File
Description: Anlagenraumthermostat, 0…50 °C, Hysterese 1,3 K, TR, Außeneinstellung, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: KA010001, Anlagenraumthermostat, 0…50 °C, Hysterese 1,3 K, TR, Außeneinstellung
In: Raum
Description: Die Anlagenraum-Thermostate RTKSA wurden speziell entwickelt für den Einsatz in Industrie-, Messe-, Traglufthallen und Gewächshäusern. Bei Verwendung als Frostschutzregler sind die höheren Toleranzen am Skalenende zu beachten.; Classification: EC011173 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: KA010001; ModelLabel: RTKSA-100.110; GlobalTradeItemNumber: 4050528074768; ProductURL: https://alre.de/produkt_KA010001
Pset_Specification - NominalLength: 0.1189 m; NominalWidth: 0.085 m; NominalDepth: 0.0667 m; NetWeight: 0.258
Pset_ALRE_ETIM_Properties - Breite: 85; Höhe: 118.9; Tiefe: 66.7; Messbereich: 0; Explosionsgeschützt: no; Schutzart (IP): IP54; Ausführung Aufnehmer/Fühler: kapillar; Max. Mediumtemperatur (Dauerbetrieb): 57; Max. Spannung der Kontakte: 230; Kontaktverriegelung: no; Max. Kontaktbelastung: 16; Differenzwert: 1.3; Differenz verstellbar: no; ETIM-Klasse: EC011173; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-KA010001.pdf
